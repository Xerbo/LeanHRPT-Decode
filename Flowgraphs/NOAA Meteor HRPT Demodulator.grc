options:
  parameters:
    author: Xerbo
    category: Custom
    generate_options: qt_gui
    id: noaameteorhrptdemod
    output_language: python
    run_options: run
    title: NOAA/Meteor HRPT Demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 600*1109
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*math.pi*50000/samp_rate
    min_freq: '-2*math.pi*50000/samp_rate'
    w: math.pi/150
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.002'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: sym_rate
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, 0.6, 101)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bpsk
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bpsk
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_imag_1, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_imag_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_1, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', analog_agc_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
